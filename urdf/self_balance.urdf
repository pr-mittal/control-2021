Commit message: LQR working model

File: urdf/self_balance.urdf (robot description, URDF)
Before this commit: robot self_balance, 3 links, 2 joints
Links:
- link Untitled.001: mass 0.001 -> 1
- link Untitled.002: mass 0.001 -> 1
